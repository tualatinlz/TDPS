# Keil uVision project BusMotor.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BusMotor +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CORE;..\FWlib\inc;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\SYSTEM\usart;..\HARDWARE\Timer;..\HARDWARE\PS2;..\HARDWARE\Beep;..\HARDWARE\Control_app;..\HARDWARE\Servo;..\HARDWARE\MOTOR;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ENCODER;..\HARDWARE\EXTI;..\HARDWARE\ULN;..\HARDWARE\Traversing
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Timer/: timer.c
    ../HARDWARE/PS2/: Ps2.c
    ../HARDWARE/Beep/: beep.c
    ../HARDWARE/Control_app/: control_app.c
    ../HARDWARE/Servo/: servor.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c oled_user.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ULN/: ULN.c
    ../HARDWARE/Traversing/: Traversing.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c system_stm32f10x.c
    ../SYSTEM/usart/: usart.c
  group USER
    ../USER/: main.c stm32f10x_it.c Control.c UI.c
software components: CMSIS:CORE 5.1.1
